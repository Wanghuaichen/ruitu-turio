# Keil uVision project TuRio.uvprojx, settings and files
target TuRio (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TuRio
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\StdPeriph_Driver\inc;..\User\Api;..\User\Main;..\User\Ocp;..\User\Bfm;..\Libraries\CMSIS;..\User\Task;..\User\App;..\ThirdLib\socket;..\Interfaces;..\ThirdLib\cjson
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Libraries/CMSIS
    ../Libraries/CMSIS/: misc.c
  group Libraries/Startup
    ../Libraries/Startup/: startup_stm32f10x_hd.s
  group Libraries/StdPeriph_Driver
    ../Libraries/StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/Main
    ../User/Main/: main.c Param.c stm32f10x_it.c system_stm32f10x.c
  group User/Ocp
    ../User/Ocp/: ocp_can.c ocp_gpio.c ocp_uart.c ocp_spi.c ocp_adc.c ocp_timer.c
  group User/Bfm
    ../User/Bfm/: bfm_w5500.c
  group User/Api
    ../User/Api/: api_dataPro.c api_motor.c api_battery.c
  group User/App
    ../User/App/: app_can.c app_config.c app_uart.c app_tcp.c app_gpio.c app_pt100.c
  group User/Task
    ../User/Task/: private.c task.c
  group ThirdLib/Socket
    ../ThirdLib/socket/: socket.c utility.c w5500_config.c
  group Interfaces
    ../Interfaces/: tcp_demo.c malloc.c
  group ThirdLib/cJson
    ../ThirdLib/cjson/: cJSON.c
